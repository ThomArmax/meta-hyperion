require hyperion_1.1.1.inc
require hyperion-qt4.inc

DEPENDS += "\
	qt4-embedded \
	"

RDPENDS_${PN} = "\
	qt4-embedded \
	"
