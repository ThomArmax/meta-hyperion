# Add specific package config to Raspberry Pi
PACKAGECONFIG_append = " \
    dispmanx \
    ws2812b \
    ws281x \
    "
