require hyperion.inc

SRC_URI += " \
    file://0001-use-yocto-protobuf.patch \
    "

SRCREV = "d3713a8ea9116c92f0a219b7114f1a8709462979"

PR = "0"
PV = "1.03.2"
