require hyperion-image-base.inc

DESCRIPTION = "A minimal console-only image with hyperion"
